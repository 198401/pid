# Keil uVision project PID.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ADuC7024 Analog Devices
  cpu: IRAM(0x10000-0x11FFF) IROM(0x80000-0x8F7FF) CLOCK(32768) CPUTYPE(ARM7TDMI)
  output: PID +hex
  c flags: Optim=4
  c misc: --c99
  c include: ..\bsp\port;..\modbus\ascii;..\modbus\rtu;..\modbus\include;..\src;..\FlashEE;..\bsp\ht1622
  memory RVCT4: ROM 0x80000 size 0xf800
  memory RVCT9: RAM 0x10000 size 0x2000
  group src
    ../src/: Startup.s main.c
  group bsp
    ../bsp/port/: portevent.c portserial.c porttimer.c
  group modbus
    ../modbus/: mb.c
    ../modbus/ascii/: mbascii.c
    ../modbus/rtu/: mbcrc.c mbrtu.c
    ../modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
  group rtos
    ../rtos/: RTX_Config.c
  group flash
    ../FlashEE/: iap.c
  group lcd
    ../bsp/ht1622/: HT1622.c
  group hmi
    ../src/: Hmi.c
